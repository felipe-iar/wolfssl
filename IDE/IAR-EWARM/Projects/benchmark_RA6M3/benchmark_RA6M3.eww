<?xml version="1.0" encoding="UTF-8" standalone="yes"?>
<workspace>
    <project>
        <path>$WS_DIR$\benchmark_RA6M3.ewp</path>
    </project>
    <batchBuild/>
</workspace>
