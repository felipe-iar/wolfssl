# IAR project wolfCrypt-test.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: ewarm; WOLFSSL_USER_SETTINGS
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\..; ..\; ..\..\..\..\..
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: ewarm
  AARM.AUserIncludes: ..\..\..\..
  OBJCOPY.OOCOutputFile: wolfCrypt-test.bin
  ILINK.IlinkOutputFile: test.out
  ILINK.IlinkIcfFile: ..\common\wolfssl.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Config
    ../: user_settings.h
  group Lib
    ../lib/ewarm/Exe/: wolfSSL-Lib.a
  group Source
    ../common/: minimum-startup.c
    ./: test-main.c
    ../../../../wolfcrypt/test/: test.c
