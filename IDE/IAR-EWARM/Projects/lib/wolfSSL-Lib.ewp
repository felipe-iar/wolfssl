# IAR project wolfSSL-Lib.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: WOLFSSL_USER_SETTINGS; WOLFSSL_RENESAS_RA6M3G
  ICCARM.CCDiagSuppress: Pa050,Pa089,Pe177,Pa181
  ICCARM.IExtraOptions: --silent
  ICCARM.CCIncludePath2: ../benchmark_RA6M3/ra/arm/CMSIS_5/CMSIS/Core/Include; ../benchmark_RA6M3/ra/aws/amazon-freertos/freertos_kernel/include; ../benchmark_RA6M3/ra/aws/amazon-freertos/libraries/freertos_plus/standard/freertos_plus_tcp/include; ../benchmark_RA6M3/ra/fsp/inc; ../benchmark_RA6M3/ra/fsp/inc/api; ../benchmark_RA6M3/ra/fsp/inc/instances; ../benchmark_RA6M3/ra/fsp/src/rm_freertos_port; ../benchmark_RA6M3/ra_cfg/aws; ../benchmark_RA6M3/ra_cfg/fsp_cfg; ../benchmark_RA6M3/ra_cfg/fsp_cfg/bsp; ../benchmark_RA6M3/ra_gen; ../benchmark_RA6M3/src; ..; ..\..\..\..; ..\..\..\..\..
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: CyaSSL-Full.srec
  ILINK.IlinkOutputFile: CyaSSL-Full.out
  ILINK.IlinkIcfFile: CyaSSL-Full.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group Config
    ../../../../wolfssl/wolfcrypt/: settings.h
    ../: user_settings.h
  group wolfCrypt
    ../../../../wolfcrypt/src/: aes.c arc4.c asm.c asn.c blake2b.c camellia.c chacha.c chacha20_poly1305.c cmac.c coding.c compress.c cpuid.c curve25519.c des3.c dh.c dsa.c ecc.c ecc_fp.c ed25519.c error.c fe_low_mem.c fe_operations.c ge_low_mem.c ge_operations.c hash.c hc128.c hmac.c idea.c integer.c logging.c md2.c md4.c md5.c memory.c pkcs12.c pkcs7.c poly1305.c pwdbased.c rabbit.c random.c ripemd.c rsa.c sha.c sha256.c sha3.c sha512.c signature.c sp_arm32.c sp_arm64.c sp_c32.c sp_c64.c sp_int.c srp.c tfm.c wc_encrypt.c wc_port.c wolfevent.c wolfmath.c
  group wolfSSL
    ../../../../src/: crl.c internal.c keys.c ocsp.c sniffer.c ssl.c tls.c tls13.c wolfio.c
